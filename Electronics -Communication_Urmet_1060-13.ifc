Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-04-08T11:28:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Alternate UI 17.21.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 08 11:28:15 2021 * Host: URD0938 * Database: C:\Users\DNLMRCUD\AppData\Local\Temp\{CD1B0012-A9CF-470B-A378-6EC45D6E44C9}\ifc * Database version: 5507 * Database creation date: Thu Apr 08 11:28:13 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 08 11:28:13 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 08 11:28:13 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Livello 1
LongName: Livello 1; Elevation: 0 mm

# IfcBuildingElementProxy: Electronics -Communication_Urmet_1060-13, Electronics -Communication_Urmet_1060-13:Electronics -Communication_Urmet_1060-13:131772
In: Livello 1
Type - Classification: 1060/13 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Electronics -Communication_Urmet_1060-13
Pset_ManufacturerTypeInformation - Manufacturer: Urmet S.p.A. Urmet S.p.A.
